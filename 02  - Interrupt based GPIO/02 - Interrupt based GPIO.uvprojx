# Keil uVision project 02 - Interrupt based GPIO.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x00200000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 02 - Interrupt based GPIO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\STM32F4 Peripherals\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Src
    ../STM32F4 Peripherals/Src/: STM32F4_GPIO.c
  group Inc
    ../STM32F4 Peripherals/Inc/: STM32F4_GPIO.h
  group Application/User
    ../Application.User/: led_it.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.6.2
