# Keil uVision project Learn.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Learn
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Application.User;.\STM32F4 Peripherals\Inc;.\STM32F4 Peripherals\Src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Application.User/: led_it.c main.c Spi_master.c
  group Inc
    ./STM32F4 Peripherals/Inc/: STM32F4_GPIO.h STM32F4_I2C.h STM32F4_SPI.h
  group Src
    ./STM32F4 Peripherals/Src/: STM32F4_GPIO.c STM32F4_SPI.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.6.2
